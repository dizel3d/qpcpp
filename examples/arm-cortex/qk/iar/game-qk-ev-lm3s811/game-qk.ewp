# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050,Pe368
  ICCARM.CCIncludePath2: .; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cortex\qk\iar; cmsis
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; Q_SPY; STACK_SIZE=600
  group CMSIS
    cmsis/: core_cm3.c core_cm3.h lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group QP-Debug
    ../../../../../ports/arm-cortex/qk/iar/dbg/: libqep_cortex-m3.a libqf_cortex-m3.a libqk_cortex-m3.a
  group QP-Release
    ../../../../../ports/arm-cortex/qk/iar/rel/: libqep_cortex-m3.a libqf_cortex-m3.a libqk_cortex-m3.a
  group QP-Spy
    ../../../../../ports/arm-cortex/qk/iar/spy/: libqep_cortex-m3.a libqf_cortex-m3.a libqk_cortex-m3.a libqs_cortex-m3.a
  group Source
    ./: bsp.cpp bsp.h display96x16x1.c display96x16x1.h game.h lm3s_config.h main.cpp mine1.cpp mine2.cpp missile.cpp ship.cpp tunnel.cpp
